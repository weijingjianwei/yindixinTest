# IAR project ColorMixingTask.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Realplum IndieSemi Realplum
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: Function_Blocks\ColorMixingTask; Function_Blocks\GTimer; usr\library; usr\common; usr\leds; inc; drivers; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; lib\downloader\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ColorMixingTask.out
  group includes
    usr/common/: appConfig.h taskManager.h
    function_blocks/colormixingtask/: colorFormula.h
    usr/library/: colorMixingTask.h softTimerTask.h
    usr/leds/: ledParamTables.h
    drivers/hal/inc/: pwm_device.h
  group src
    function_blocks/colormixingtask/: colorFormula.c ColorMixingTask.c
