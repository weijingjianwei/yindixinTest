# IAR project LedLibrary.ewp, settings and files
configuration DOMINANT_D6RTB_HKG_CS1124 (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: Function_Blocks\ColorMixingTask; Function_Blocks\GTimer; usr\library; usr\common; usr\leds; inc; drivers; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; lib\downloader\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: LedLibrary.out
configuration OSRAM_LRTB_GVSG (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Realplum IndieSemi Realplum
  General.CoreVariant: 34
  ICCARM.CCIncludePath2: usr\library; usr\common; Function_Blocks\ColorMixingTask; inc; drivers; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  group (top)
    Function_Blocks/LedLibrary/: LedParamTables_DOMINANT_D6RTB_HKG_CS1124.c LedParamTables_OSRAM_LRTB_GVSG.c
