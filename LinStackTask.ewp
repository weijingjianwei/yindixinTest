# IAR project LinStackTask.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Realplum IndieSemi Realplum
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: Function_Blocks\ColorMixingTask; Function_Blocks\GTimer; usr\library; usr\common; usr\leds; inc; drivers; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; lib\downloader\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: LinStackTask.out
  group includes
    usr/library/: linStackTask.h
  group src
    Function_Blocks/LinStackTask/: LinStackTask.c
