<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Realplum_app.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Realplum_bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
