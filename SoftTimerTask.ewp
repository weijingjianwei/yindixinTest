# IAR project SoftTimerTask.ewp, settings and files
configuration Library (ARM)
  General.OGChipSelectEditMenu: Realplum IndieSemi Realplum
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __CHECK_DEVICE_DEFINES
  ICCARM.CCIncludePath2: usr\library; usr\common; Function_Blocks\GTimer; inc; drivers; drivers\core\inc; drivers\hal\inc; drivers\hdf; drivers\hdf\inc; drivers\hdf\sfrs; drivers\hwcfg\inc; drivers\api\inc; lib\downloader\inc; $TOOLKIT_DIR$\CMSIS\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: SoftTimerTask.out
  group includes
    usr/library/: softTimerTask.h
  group src
    function_blocks/softtimertask/: softTimerTask.c
